# Keil uVision project RavenOS.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RavenOS +hex
  c flags: Optim=1 wLevel=2
  c define: TARGET_IS_TM4C123_RB1 PART_TM4C123GH6PM
  c include: .\RTE\RTOS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./RTE/RTOS/Source/: retarget.c main.c peripherals.c thread0.c thread1.c thread2.c thread3.c trace.c kernel.c
  group ::CMSIS Driver
    D:/Keil_v5/ARM/PACK/RavenOS/TM4C123GH6PM_UART/1.0.0/RTE/CMSIS/Driver/: USART_TM4C123.c
  group ::Device
    RTE/Device/TM4C123GH6PM/: startup_TM4C123.s system_TM4C123.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0, CMSIS Driver:USART:TM4C123GH6PM 2.01
